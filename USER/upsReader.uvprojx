# Keil uVision project upsReader.uvprojx, settings and files
target upsReader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F130F6 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.0
  cpu: IRAM(0x20000000,0x01000) IROM(0x08000000,0x08000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: upsReader
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\FUNC;..\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ./: main.c gd32f1x0_it.c
  group APP
    ../APP/: ups0Thread.c
  group FUNC
    ../FUNC/: upsContext.c
  group HARDWARE
    ../HARDWARE/: usart.c led.c fwdgt.c spi.c
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:GD32F1x0_StdPeripherals:DMA 3.2.0, Device:GD32F1x0_StdPeripherals:FWDGT 3.2.0, Device:GD32F1x0_StdPeripherals:GPIO 3.2.0, Device:GD32F1x0_StdPeripherals:MISC 3.2.0, Device:GD32F1x0_StdPeripherals:RCU 3.2.0, Device:GD32F1x0_StdPeripherals:SPI_I2S 3.2.0, Device:GD32F1x0_StdPeripherals:USART 3.2.0, Device:GD32F1x0_libopt 3.2.0, Device:Startup 3.2.0
